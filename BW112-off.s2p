!  2-Port S-parameters saved by WinCal
! VAR MeasName=S-Parameters (CALIBRATED_DATA) read from VNA (E8364A)
! VAR MeasDate=10/8/2010 5:32:58 PM
! VAR NAME=3(40)-off
! VAR FILENAME=3(40)-off.s2p
! VAR DATE=10/8/2010 5:32:58 PM
! VAR PHYS_PORTS=1,2
# Hz S RI R 50
! Worked out from all points (weakly coupled two-port):
!   501 points, 45 MHz to 20 GHz, reference 50 ohm
!   highest |S21| = -28.51 dB at 19.96 GHz (marker M1); lowest = -75.6 dB at 84.91 MHz (marker M2)
!   lowest |S11| = -46.1 dB at 11.82 GHz (marker M3), VSWR 1.01, Z = 50.3 - j0.363 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -3.7 to -1.3 dB; largest |S21 - S12| = 0.0019
!   the Smith chart shows 10.14 GHz to 14.17 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 45 MHz  -18.7  -63.2  -57.2  -1.4
! 84.91 MHz  -19.5  -75.6  -74.7  -1.4
! 3.397 GHz  -20.1  -51.6  -51.9  -1.7
! 6.71 GHz  -23.0  -55.3  -55.5  -2.0
! 8.386 GHz  -17.1  -55.7  -56.2  -2.3
! 8.666 GHz  -42.0  -52.9  -52.7  -2.3
! 8.945 GHz  -25.6  -51.3  -51.2  -2.2
! 9.304 GHz  -27.8  -52.1  -52.0  -2.3
! 9.583 GHz  -22.1  -49.3  -49.1  -2.3
! 10.02 GHz  -19.3  -50.5  -50.5  -2.5
! 11.42 GHz  -20.9  -44.3  -44.2  -2.8
! 11.82 GHz  -46.1  -41.7  -41.8  -2.8
! 12.62 GHz  -14.2  -39.0  -38.9  -3.0
! 13.37 GHz  -16.3  -35.5  -35.5  -3.2
! 14.65 GHz  -36.9  -32.4  -32.4  -3.4
! 15.01 GHz  -14.8  -32.6  -32.6  -3.4
! 16.69 GHz  -20.2  -31.6  -31.6  -3.6
! 17.69 GHz  -21.0  -32.0  -32.0  -3.7
! 18 GHz  -13.0  -31.6  -31.5  -3.6
! 19.24 GHz  -12.5  -29.6  -29.6  -3.6
! 19.96 GHz  -17.0  -28.5  -28.4  -3.6
! 20 GHz  -22.2  -28.6  -28.6  -3.6
